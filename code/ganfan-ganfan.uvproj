# Keil uVision project ganfan-ganfan.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: ganfan-ganfan +hex
  c flags: Optimize=8 SizeSpeed=1
  group Driver
    ./: STARTUP.A51 delay.c booth.c motor.c timer.c uart.c
  group User
    ./: code.c
